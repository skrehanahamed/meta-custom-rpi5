# ==============================================================================
# Enable Hardware DRM/KMS EGLFS Acceleration for Raspberry Pi 5 VideoCore VII
# ==============================================================================
PACKAGECONFIG:append = " gbm kms"
